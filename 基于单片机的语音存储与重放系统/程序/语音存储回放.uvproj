# Keil uVision project 语音存储回放.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 语音存储回放 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 语音存储回放.c ISD4004.c key.c LCD1602.c
